#include <stdint.h>
#include <stdlib.h>
#include <stdio.h>
#include <string.h>
#include <fcntl.h>
#include <unistd.h>

uint32_t seed = 0x5E31BC3;
uint32_t enc_key_idx = 3;
uint32_t dec_key_idx = 18;

uint8_t key[] = { 0x59, 0x5E, 0x78, 0x2E, 0x47, 0x20, 0x85, 0xE1, 0x6C, 0x60, 0xA6, 0xDF, 0xB2, 0x77, 0x0C, 0x78, 0x6A, 0xDF, 0x92 };

uint8_t sbox[256] = {
    0x21, 0x10, 0x1A, 0xE6, 0x15, 0xC8, 0xC5, 0x44, 0x96, 0xA0, 0x5D, 0xC7, 0xB8, 0xAE, 0x55, 0x30, 
    0x1F, 0x04, 0xFC, 0x1B, 0xFE, 0xC4, 0x35, 0xEF, 0xD1, 0x77, 0x43, 0x61, 0xC9, 0x9B, 0xE5, 0xA3, 
    0x0C, 0x40, 0x2F, 0xC0, 0xCF, 0x4D, 0xE7, 0xB0, 0x70, 0xD4, 0xFB, 0x6C, 0x88, 0xC1, 0x16, 0x65, 
    0xE9, 0x36, 0x80, 0x51, 0x53, 0x0A, 0xA2, 0xEA, 0xDB, 0x05, 0x01, 0x0B, 0x8D, 0x4A, 0x68, 0x47, 
    0x25, 0x99, 0x02, 0xC6, 0xE0, 0x2B, 0x2D, 0x73, 0xF3, 0xFA, 0x27, 0x7E, 0xBB, 0xCA, 0x06, 0xA4, 
    0xF9, 0x98, 0x97, 0xB5, 0x09, 0x12, 0x0E, 0x4F, 0x14, 0xFD, 0x41, 0xF7, 0x83, 0x6D, 0x52, 0x07, 
    0x75, 0x93, 0x74, 0x6F, 0x5A, 0xB1, 0xAD, 0x28, 0x31, 0x18, 0x69, 0xA7, 0x3F, 0x48, 0xF1, 0x81, 
    0x85, 0x92, 0xDD, 0x3E, 0x3A, 0xE8, 0xC3, 0x34, 0xF4, 0x7F, 0x57, 0x62, 0x3B, 0xA8, 0xBE, 0xBC, 
    0xD7, 0xAA, 0xCC, 0xA5, 0xBA, 0xAB, 0xDE, 0xAF, 0x8B, 0xE3, 0x58, 0x1E, 0x3D, 0x4B, 0xD3, 0xA1, 
    0x19, 0x84, 0x23, 0x95, 0xDC, 0xEB, 0x32, 0x9E, 0x72, 0x5C, 0x46, 0xA9, 0x5F, 0xEE, 0x89, 0x1C, 
    0x49, 0x9D, 0x6B, 0x5E, 0x9F, 0x3C, 0x7D, 0x4E, 0xCD, 0x13, 0x2C, 0x2E, 0x56, 0x7A, 0xF2, 0xE1, 
    0xD6, 0x79, 0x8A, 0x63, 0x9C, 0x54, 0xDA, 0x20, 0x0D, 0x76, 0xDF, 0xC2, 0xEC, 0x50, 0xD0, 0x38, 
    0x67, 0xE4, 0xB2, 0x00, 0xB7, 0x8C, 0xF0, 0x5B, 0x82, 0x59, 0xE2, 0xAC, 0xD9, 0xD2, 0x08, 0x6A, 
    0x45, 0xBF, 0xD8, 0x94, 0x4C, 0x17, 0x8E, 0x7B, 0xF8, 0xCE, 0x42, 0x39, 0x29, 0x2A, 0xBD, 0x0F, 
    0x66, 0x22, 0x03, 0x6E, 0x1D, 0x60, 0x8F, 0x26, 0xF6, 0x37, 0x11, 0xB4, 0x9A, 0x91, 0xED, 0x64, 
    0x7C, 0x90, 0xB9, 0xB3, 0xB6, 0xF5, 0xCB, 0x86, 0x87, 0x33, 0x78, 0x24, 0xA6, 0xD5, 0x71, 0xFF
};

uint8_t _index(uint8_t c)
{
    return (uint8_t*)memchr(sbox, c, 256) - &sbox[0];
}

uint32_t rotate_right(uint32_t d)
{
    return (d << 31) | (d >> 1);
}

uint32_t rotate_left(uint32_t d)
{
    return (d << 1) | (d >> 31);
}

uint32_t encrypt_one_round(uint32_t d)
{
    uint32_t v10 = (key[enc_key_idx]) | (key[enc_key_idx-1] << 8) | (key[enc_key_idx-2] << 16) | (key[enc_key_idx-3] << 24);
    uint32_t x = sbox[d & 0xff] | (sbox[d >> 8 & 0xff] << 8) | (sbox[d >> 16 & 0xff] << 16) | (sbox[d >> 24 & 0xff] << 24);
    uint32_t c = rotate_right(x);
    if ( ++enc_key_idx == 19 )
        enc_key_idx = 3;
    return v10 ^ c;
}

uint32_t decrypt_one_round(uint32_t d)
{
    uint32_t v10 = (key[dec_key_idx]) | (key[dec_key_idx-1] << 8) | (key[dec_key_idx-2] << 16) | (key[dec_key_idx-3] << 24);
    uint32_t x = rotate_left(v10 ^ d);
    uint32_t p = _index(x & 0xff) | (_index(x >> 8 & 0xff) << 8) | (_index(x >> 16 & 0xff) << 16) | (_index(x >> 24 & 0xff) << 24);
    if ( --dec_key_idx == 2 )
        dec_key_idx = 18;

    return p;
}

uint32_t encrypt_16_rounds(uint32_t d)
{
    d ^= seed;
    for ( int i = 0; i < 16; ++i )
		d = encrypt_one_round(d);

	return seed = d;
}

uint32_t decrypt_16_round(uint32_t d)
{
    for ( int i = 0; i < 16; ++i )
		d = decrypt_one_round(d);

	return d ^ seed;
}

int main(int argc, char *argv[])
{
    int fd = open("./flag.locked_65d0360739a01c5737108cc172ea5c8681249c74", O_RDWR);

    char magic[8];
    read(fd, magic, 8);

    if ( memcmp(magic, "_LOCKED_", 8) ) {
        printf("Invalid header!\n");
        return 1;
    }

    uint32_t size;
    read(fd, &size, 4);
    printf("File size = %d\n", size);

    uint32_t* buf = malloc(size);
    uint32_t* out = malloc(size - 12);
    read(fd, buf, size);

    for ( int i = 0; i < size / 4; ++i ) {
        out[i] = decrypt_16_round(buf[i]);
        seed = buf[i];
    }

    int fout = open("./flag.png", O_CREAT|O_RDWR);
    write(fout, out, size - 12);

    close(fd);
    close(fout);
    
	return 0;
}

// ASIS{There_aRe_real_Rans0mw4re_f0r_Linux_to0!!}
