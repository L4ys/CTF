0001: idx = 288 (word)
0000: idx = idx + 11 (word)
0001: data[idx] = data[idx] + 87 (byte)
0002: idx = idx + 22 (word)
0003: data[idx] = data[idx] + 52 (byte)
0004: idx = idx + -22 (word)
0005: data[idx] = data[idx] + 109 (byte)
0006: idx = idx + 26 (word)
0007: data[idx] = data[idx] + 56 (byte)
0008: idx = idx + -13 (word)
0009: data[idx] = data[idx] + 44 (byte)
000A: idx = idx + -10 (word)
000B: data[idx] = data[idx] + 84 (byte)
000C: idx = idx + 7 (word)
000D: data[idx] = data[idx] + 179 (byte)
000E: idx = idx + -14 (word)
000F: data[idx] = data[idx] + 92 (byte)
0010: idx = idx + 10 (word)
0011: data[idx] = data[idx] + 15 (byte)
0012: idx = idx + 3 (word)
0013: data[idx] = data[idx] + 88 (byte)
0014: idx = idx + -1 (word)
0015: data[idx] = data[idx] + 114 (byte)
0016: idx = idx + 11 (word)
0017: data[idx] = data[idx] + 37 (byte)
0018: idx = idx + 6 (word)
0019: data[idx] = data[idx] + 175 (byte)
001A: idx = idx + -31 (word)
001B: data[idx] = data[idx] + 100 (byte)
001C: idx = idx + 13 (word)
001D: data[idx] = data[idx] + 3 (byte)
001E: idx = idx + -2 (word)
001F: data[idx] = data[idx] + 32 (byte)
0020: idx = idx + -3 (word)
0021: data[idx] = data[idx] + 181 (byte)
0022: idx = idx + -7 (word)
0023: data[idx] = data[idx] + 48 (byte)
0024: idx = idx + 18 (word)
0025: data[idx] = data[idx] + 52 (byte)
0026: idx = idx + 10 (word)
0027: data[idx] = data[idx] + 129 (byte)
0028: idx = idx + -9 (word)
0029: data[idx] = data[idx] + 68 (byte)
002A: idx = idx + 7 (word)
002B: data[idx] = data[idx] + 39 (byte)
002C: idx = idx + -30 (word)
002D: data[idx] = data[idx] + 204 (byte)
002E: idx = idx + 25 (word)
002F: data[idx] = data[idx] + 30 (byte)
0030: idx = idx + -7 (word)
0031: data[idx] = data[idx] + 91 (byte)
0032: idx = idx + 3 (word)
0033: data[idx] = data[idx] + 2 (byte)
0034: idx = idx + 6 (word)
0035: data[idx] = data[idx] + 212 (byte)
0036: idx = idx + -22 (word)
0037: data[idx] = data[idx] + 43 (byte)
0038: idx = idx + 9 (word)
0039: data[idx] = data[idx] + 113 (byte)
003A: idx = idx + 16 (word)
003B: data[idx] = data[idx] + 9 (byte)
003C: idx = idx + -29 (word)
003D: data[idx] = data[idx] + 117 (byte)
003E: idx = idx + 23 (word)
003F: data[idx] = data[idx] + 45 (byte)
0040: idx = idx + 2 (word)
0041: data[idx] = data[idx] + 13 (byte)
0042: idx = idx + 7 (word)
0043: data[idx] = data[idx] + 164 (byte)
0044: idx = idx + 3 (word)
0045: data[idx] = data[idx] + 39 (byte)
0046: idx = idx + -15 (word)
0047: data[idx] = data[idx] + 13 (byte)
0048: idx = idx + -14 (word)
0049: data[idx] = data[idx] + 218 (byte)
004A: idx = idx + 9 (word)
004B: data[idx] = data[idx] + 5 (byte)
004C: idx = idx + -10 (word)
004D: data[idx] = data[idx] + 216 (byte)
004E: idx = idx + -7 (word)
004F: data[idx] = data[idx] + 65 (byte)
0050: idx = idx + 4 (word)
0051: data[idx] = data[idx] + 125 (byte)
0052: idx = idx + 5 (word)
0053: data[idx] = data[idx] + 225 (byte)
0054: idx = idx + -7 (word)
0055: data[idx] = data[idx] + 97 (byte)
0056: idx = idx + -3 (word)
0057: data[idx] = data[idx] + 67 (byte)
0058: idx = idx + 27 (word)
0059: data[idx] = data[idx] + 18 (byte)
005A: idx = idx + -1 (word)
005B: data[idx] = data[idx] + 68 (byte)
005C: idx = idx + 8 (word)
005D: data[idx] = data[idx] + 22 (byte)
005E: idx = idx + -30 (word)
005F: data[idx] = data[idx] + 119 (byte)
0060: idx = idx + 29 (word)
0061: data[idx] = data[idx] + 110 (byte)
0062: idx = idx + -11 (word)
0063: data[idx] = data[idx] + 36 (byte)
0064: idx = idx + -9 (word)
0065: data[idx] = data[idx] + 4 (byte)
0066: idx = idx + 18 (word)
0067: data[idx] = data[idx] + 34 (byte)
0068: idx = idx + -16 (word)
0069: data[idx] = data[idx] + 227 (byte)
006A: idx = idx + -5 (word)
006B: data[idx] = data[idx] + 5 (byte)
006C: idx = idx + -6 (word)
006D: data[idx] = data[idx] + 23 (byte)
006E: idx = idx + 8 (word)
006F: data[idx] = data[idx] + 49 (byte)
0070: idx = idx + 18 (word)
0071: data[idx] = data[idx] + 84 (byte)
0072: idx = idx + -2 (word)
0073: data[idx] = data[idx] + 10 (byte)
0074: idx = idx + -11 (word)
0075: data[idx] = data[idx] + 30 (byte)

0077: NOP
0077: RA = 255 (word)
0078: idx = 513 (word)
0079: jmp offset = (RA < 0) (word)
007A: jmp offset = 1 (word)
007B: jmp offset = 4 (word)
007C: data[idx] = RA (byte)
007D: idx = idx + 1 (word)
007E: RA = RA + -1 (word)
007F: jmp offset = -7 (word)

0081: NOP
0081: idx = 256 (word)
0082: data[idx] = 0 (word)
0083: idx = 258 ; k (word)
0084: data[idx] = 0 (word)
0085: idx = 260 ; i (word)
0086: data[idx] = 0 (word)
0087: idx = 262 ; j (word)
0088: data[idx] = 0 (word)
0089: idx = 260 ; i (word)

008A: RA = data[idx] + -39 (word)
008B: jmp offset = (RA == 0) (word)
008C: jmp offset = 1 (word)
008D: jmp offset = 43 (word)

// RB = data[i]
008E: idx = 260 ; i (word)
008F: idx = data[idx] (word)
0090: RB = data[idx] (word)
// RA = j
0091: idx = 262 ; j (word)
0092: RA = data[idx] (word)

// RB *= 2 ** RA
0093: jmp offset = (RA == 0) (word)
0094: jmp offset = 1 (word)
0095: jmp offset = 3 (word)

0096: RB = RB + RB (word) ; RB *= 2
0097: RA = RA + -1 (word) ; RA -- 
0098: jmp offset = -6 (word)

// [266:267] = RB
0099: idx = 266 (word)
009A: data[idx] = RB (word)

// RA = [266] + [267]
009B: RA = data[idx] (word)
009C: idx = idx + 1 (word)
009D: RA = RA + data[idx] (word)

// RA += [512 + k]
009E: idx = 258 ; k (word)
009F: idx = data[idx] + 512 (word)
00A0: RA = RA + data[idx] (byte)
// RB = [288 + i]
00A1: idx = 260 ; i (word)
00A2: idx = data[idx] + 288 (word)
00A3: RB = data[idx] (word)
// k = RB
00A4: idx = 258 ; k (word)
00A5: data[idx] = RB (word)
// RA += [512 + RB]
00A6: idx = RB + 512 (word)
00A7: RA = RA + data[idx] (byte)

00A8: idx = 256 (word)
00A9: jmp offset = (RA == 0) (word)
00AA: jmp offset = 1 (word)
00AB: jmp offset = 2 (word)
00AC: data[idx] = 1 (word)
00AD: jmp offset = 2 (word)
00AE: data[idx] = data[idx] (word)
00AF: RA = RA (word)
00B0: idx = 260 ; i (word)
00B1: data[idx] = data[idx] + 1 (word)
00B2: idx = 262 ; j (word)
00B3: data[idx] = data[idx] + 1 (word)
00B4: RA = data[idx] + -8 (word)
00B5: jmp offset = (RA == 0) (word)
00B6: jmp offset = 1 (word)
00B7: data[idx] = 0 (word)
00B8: jmp offset = -48 (word)
00B9: idx = 256 (word)
00BA: RA = data[idx] (word)
